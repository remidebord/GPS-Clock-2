# Keil uVision project template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --cpp
  c include: .\inc;.\lib\api\inc;.\lib\cmsis\inc;.\lib\system\inc;.\lib\misc\inc;.\inc\Items
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\lib\system\src\stm32f0xx.sct
  group system
    ./lib/system/src/: startup_stm32f051x8.s system_stm32f0xx.c sys.cpp
  group cmsis
    ./lib/cmsis/src/: cmsis_nvic.c
    ./lib/cmsis/inc/: cmsis.h cmsis_nvic.h core_cm0.h core_cmFunc.h core_cmInstr.h
  group api
    ./lib/api/src/: Common.c CircularBuffer.cpp Delay.c GPIO.cpp Digital.cpp Analog.cpp Timer.cpp Serial.cpp I2C.cpp SPI.cpp Memory.cpp Power.cpp Watchdog.cpp RTC.cpp
  group user
    ./src/: main.c Init.c Loop.c Config.cpp Callbacks.c
  group items
    ./src/Items/: Altitude.cpp Clock.cpp Fix.cpp Satellites.cpp Temperature.cpp
  group lib
    ./lib/misc/src/: Brightness.cpp Button.cpp DS3231.cpp Encoder.cpp GPS.cpp SevenSeg.cpp Timezone.cpp
    ./src/: Menu.cpp
    ./lib/misc/inc/: Grid.h
